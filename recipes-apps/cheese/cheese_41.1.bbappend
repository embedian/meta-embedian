# Fix GNOME_MIRROR location change and override it

GNOME_MIRROR = "https://download.gnome.org/sources/"
