# Fix broken link due to github does not support git protocol

SRC_URI = "git://github.com/protocolbuffers/protobuf.git;protocol=https \
	"
