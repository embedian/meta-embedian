# Fix build fail for xwayland

PACKAGECONFIG_remove = "x11"
