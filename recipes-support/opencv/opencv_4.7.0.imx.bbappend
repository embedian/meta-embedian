# Fix opencv do_fetch failure
SRCREV_opencv:forcevariable = "3acf6a50fcb4f774728d2338553ad646ccc14b14"
