# Fix broken link due to the default branch switch from master to main

SRC_URI = "git://git.kernel.org/pub/scm/utils/rt-tests/rt-tests.git;branch=main"

