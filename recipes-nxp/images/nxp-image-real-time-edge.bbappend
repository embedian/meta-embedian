IMAGE_INSTALL:remove = " \
    packagegroup-real-time-edge-rtos \
    packagegroup-harpoon \
"
